Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-07-20T18:29:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 20 18:29:50 2018 * Host: B3ROBRAWR2788 * Database: C:\Users\AVIT\AppData\Local\Temp\{16FB5D3B-8EB6-4337-8C9F-920274FEC336}\ifc * Database version: 5507 * Database creation date: Fri Jul 20 18:29:48 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Jul 20 18:29:48 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 20 18:29:48 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcTransformer: TRIO-50.0-TL-OUTD SX-SX, E_Inverter_F_MEPcontent_ABB_String Inverter_TRIO 50 TL OUTD_INT-EN:TRIO-50.0-TL-OUTD SX-SX:1292728
In: V00
Type - PredefinedType: INVERTER; Material: Color RGB 015-020-015, Color RGB 255-000-000, Color RGB 141-149-155, Color RGB 087-093-094, Color RGB 085-085-085, Color RGB 193-197-192
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 314.7 mm; Height: 723.3 mm; Width: 1475.3 mm
Type - Electrical - Loads - Absolute Maximum DC Voltage: 1000 V; Rated AC Grid Voltage: 400 V; Rated AC Power: 50000 W
Type - Electrical Engineering - Maximum DC Current: 106 A
Type - Identity Data - Article Description: Three-phase string inverter, 50000Wac, 1 MPPT, RS485, SD card slot, IP65, 12 DC input with 12+12 string fuses, Current monitoring in group of 3 inputs, DC surge protection (Type 2), DC disconnect switch, AC disconnect switch, AC surge protection (Type 2); Article Type: TRIO-50.0-TL-OUTD SX-SX; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Three-phase string inverter, 50000Wac, 1 MPPT, RS485, SD card slot, IP65, 12 DC input with 12+12 string fuses, Current monitoring in group of 3 inputs, DC surge protection (Type 2), DC disconnect switch, AC disconnect switch, AC surge protection (Type 2); EMCS Version: 4.0; ETIM Article Class: EC001747; Family Version: 11.15; GTIN: 8054529631650; Manufacturer: ABB; Manufacturer Art. No.: ABB6AGC064344; Manufacturer URL: http://new.abb.com/power-converters-inverters/solar/string/three-phase/trio-50-0kw; MEPcontent Class: INVERTER; Model: TRIO-50.0-TL-OUTD SX-SX; OmniClass Number: 23.80.30.11.14; OmniClass Title: Inverters; Product Line: UNO; Revit Version: 2017; Short Description: With DC+AC switch, fuse and DC+AC surge arrester; Type Name: TRIO-50.0-TL-OUTD SX-SX; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Back Support: Color RGB 087-093-094; Black: Color RGB 015-020-015; Dark Grey: Color RGB 085-085-085; Grey Blue: Color RGB 141-149-155; Red: Color RGB 255-000-000; White: Color RGB 193-197-192
Type - Model Properties - Number of Independent MPPT: 1
Type - Other - Category: Electrical Equipment; Family Name: E_Inverter_F_MEPcontent_ABB_String Inverter_TRIO 50 TL OUTD_INT-EN; Offset: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Elevation: 0 mm
Dimensions - Area: 2.06802 m2; Volume: 0.221848 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 400 V/1-50000 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Mark: 2
Other - Family: E_Inverter_F_MEPcontent_ABB_String Inverter_TRIO 50 TL OUTD_INT-EN: TRIO-50.0-TL-OUTD SX-SX; Family and Type: E_Inverter_F_MEPcontent_ABB_String Inverter_TRIO 50 TL OUTD_INT-EN: TRIO-50.0-TL-OUTD SX-SX; Type: E_Inverter_F_MEPcontent_ABB_String Inverter_TRIO 50 TL OUTD_INT-EN: TRIO-50.0-TL-OUTD SX-SX; Type Id: E_Inverter_F_MEPcontent_ABB_String Inverter_TRIO 50 TL OUTD_INT-EN: TRIO-50.0-TL-OUTD SX-SX
Phasing - Phase Created: 3. New Construction
